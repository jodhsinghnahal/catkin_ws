# IAR project XanBusLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2468 NXP LPC2468
  ICCARM.CCDefines: _32BIT_ARCHITECTURE; XT_FAR=; __LPC2468__; USE_CANBUF16; CANBUF_RX_PORT_BUFS=2048; CANBUF_TX_PORT_BUFS=500; CANBUF_BUFFER_EMPTY=65534; CANBUF_BUFFER_FULL=65535
  ICCARM.CCDiagSuppress: Pe231,Pe767
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\Inc; ..\..\..\..\..\Common\Pkgs\Inc; ..\..\..\..\..\Inc; ..\..\..\..\..\Targets\Inc; ..\..\Pkgs\Inc; ..\..\..\..\..\..\..\Targets\Inc; ..\..\..\..\..\..\..\Targets\NXP\LPC2468\Inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: XanBusLib.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group API/Src
    ../../../../../Common/Pkgs/API/Src/: xbaddr.c xbinit.c xbmem.c xbmltpkt.c xbmsg.c xbpack.c xbtfx.c xbtimers.c
  group Code_Inc
    ../../../../../../../../Inc/: LIB_stddefs.h LIB_stdtype.h LIB_stdtype16.h LIB_stdtype32.h xanguid.h xassert.h
  group Code_Pkg_Prot_Xb_Com_Pkgs_Inc
    ../../../../../Common/Pkgs/Inc/: cdrive.h LibCfg.h LibCore.h libenv.h msghandl.h pgn.h xbldefs.h xbmem.h
  group Code_Pkg_Prot_Xb_Inc
    ../../../../../Inc/: pgnudefs.h xbgdefs.h xbpgfns.h xbrxtx.h xbudefs.h
  group Code_Pkg_Prot_Xb_Tgt_Inc
    ../../../../Inc/: canbuf.h
  group Code_Pkg_Prot_Xb_Tgt_NXP_LPC2468_Pkgs_Inc
    ../../Pkgs/Inc/: CDrvAPI.h config.h
  group Code_Pkg_Prot_Xb_Tgt_NXP_LPC2468_Pkgs_Shim_Src/Src
    ../../Pkgs/Shim/Src/: canbuf16.c CDrive.c cdrvapi.c msghandl.c
  group Code_Pkg_Tgt_Inc
    ../../../../../../../Targets/Inc/: candrv.h Manufacturers.h
  group Code_Pkg_Tgt_NXP_LPC2468_Inc
    ../../../../../../../Targets/NXP/LPC2468/Inc/: device.h
  group Stack/Src
    ../../../../../Common/Pkgs/Stack/Src/: canframe.c dobholdr.c PGNDOb.c pgnrcvr.c pgnxmtr.c tfxlib.c
