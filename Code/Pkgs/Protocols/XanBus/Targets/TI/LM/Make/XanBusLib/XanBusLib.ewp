# IAR project XanBusLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _32BIT_ARCHITECTURE; XT_FAR=; __LM__
  ICCARM.CCIncludePath2: ..\..\..\..\..\Common\Pkgs\Inc; ..\..\..\..\..\..\..\..\Inc; ..\..\..\..\..\..\..\Targets\Inc; ..\..\Pkgs\Inc; ..\..\..\..\..\Inc; ..\..\..\..\Inc; ..\..\..\..\..\..\..\Targets\TI\LM\Inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: XanBusLib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group API/Src
    ../../../../../Common/Pkgs/API/Src/: xbaddr.c xbinit.c xbmem.c xbmltpkt.c xbmsg.c xbpack.c xbtfx.c xbtimers.c
  group Code_Inc
    ../../../../../../../../Inc/: LIB_stddefs.h LIB_stdtype.h LIB_stdtype16.h LIB_stdtype32.h xassert.h
  group Code_Pkg_Prot_Xb_Com_Pkgs_Inc
    ../../../../../Common/Pkgs/Inc/: cdrive.h LibCfg.h LibCore.h libenv.h msghandl.h pgn.h xbldefs.h xbmem.h
  group Code_Pkg_Prot_Xb_Inc
    ../../../../../Inc/: pgnudefs.h xbgdefs.h xbpgfns.h xbrxtx.h xbudefs.h
  group Code_Pkg_Prot_Xb_Tgt_Inc
    ../../../../Inc/: canbuf.h
  group Code_Pkg_Prot_Xb_Tgt_TI_LM_Pkgs_Inc
    ../../Pkgs/Inc/: CDrvAPI.h config.h
  group Code_Pkg_Prot_Xb_Tgt_TI_LM_Pkgs_Shim_Src/Src
    ../../Pkgs/Shim/Src/: canbuf.c CDrive.c cdrvapi.c msghandl.c
  group Code_Pkg_Tgt_Inc
    ../../../../../../../Targets/Inc/: candrv.h Manufacturers.h
  group Code_Pkg_Tgt_TI_LM_Inc
    ../../../../../../../Targets/TI/LM/Inc/: device.h
  group Stack/Src
    ../../../../../Common/Pkgs/Stack/Src/: canframe.c dobholdr.c PGNDOb.c pgnrcvr.c pgnxmtr.c tfxlib.c
